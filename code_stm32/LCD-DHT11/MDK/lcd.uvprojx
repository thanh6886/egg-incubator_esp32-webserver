# Keil uVision project lcd.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lcd
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: ..\USER;..\USER\UART\Inc;..\USER\DHT11\Inc;..\USER\LCD\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ../USER/: main.c
  group UART
    ../USER/UART/Src/: timer2.c usart2.c
  group LCD
    ../USER/LCD/Src/: gp_drive.c i2c_drive.c lcd_1602_drive.c PCF8574_drive.c
  group DHT11
    ../USER/DHT11/Src/: systick_time.c dht11.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
